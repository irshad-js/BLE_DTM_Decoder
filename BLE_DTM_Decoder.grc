options:
  parameters:
    generate_options: qt_gui
    id: First
    output_language: python
    title: Bluetooth Low Energy decoding
  states: {}

blocks:
- name: cut_freq
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 300e3
    step: 50e3
    stop: 1e6/2
    value: 1e6/2
  states: {}
- name: points
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '1024'
    step: '1'
    stop: '32768'
    value: '16000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: trans_freq
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 20e3
    step: 1e3
    stop: 100e3
    value: 100e3
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: D:\BLE_Decoder - Copy\Par1_decode
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: D:\BLE_Decoder - Copy\20m_Par1
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '0.0006'
    init: '0'
    low: '-0.0006'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.1'
    gain_omega: '0.01'
    mu: '0'
    omega: '10'
    omega_relative_limit: '0.01'
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cut_freq
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: trans_freq
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 1e6
    decim: '2'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 1e6/2
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: points
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', blocks_threshold_ff_0, '0']
- [analog_quadrature_demod_cf_0, '0', low_pass_filter_0_0_0_0_0_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_threshold_ff_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle_0, '0', low_pass_filter_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_file_sink_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [low_pass_filter_0, '0', analog_quadrature_demod_cf_0, '0']
- [low_pass_filter_0_0_0_0_0_0, '0', digital_clock_recovery_mm_xx_0, '0']

metadata:
  file_format: 1
